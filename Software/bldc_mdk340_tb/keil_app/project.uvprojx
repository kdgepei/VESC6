# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ..\project +hex
  AfterMake: .\output\bincombined_convert_mdk.bat
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_ENCRYPT,ARM_FPU,ARM_SINCOS,ARM_SQRT,ARM_MDK,ARM_DEBUG,ARM_BOOT,ARM_APP_NEW,ARM_EEPROM,HW_VERSION_60,BOARD_OTG_NOVBUSSENS,USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,M_PI=3.1415926f __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: --gnu --c99 --cpu=Cortex-M4.fp --fpmode=fast
  c include: .\..\;.\..\ChibiOS_3.0.2\os\common\ports\ARMCMx\devices\STM32F4xx;.\..\ChibiOS_3.0.2\os\ext\CMSIS\include;.\..\ChibiOS_3.0.2\os\ext\CMSIS\ST;.\..\ChibiOS_3.0.2\os\rt\include;.\..\ChibiOS_3.0.2\os\rt\ports\ARMCMx;.\..\ChibiOS_3.0.2\os\rt\ports\ARMCMx\compilers\GCC;.\..\ChibiOS_3.0.2\os\hal\osal\rt;.\..\ChibiOS_3.0.2\os\hal\include;.\..\ChibiOS_3.0.2\os\hal\ports\common\ARMCMx;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\DACv1;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\GPIOv2;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\I2Cv1;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\OTGv1;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\RTCv2;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\SPIv1;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\TIMv1;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\USARTv1;.\..\ChibiOS_3.0.2\os\hal\ports\STM32\STM32F4xx;.\..\ChibiOS_3.0.2\os\hal\lib\streams;.\..\ChibiOS_3.0.2\os\hal\boards\ST_STM32F4_DISCOVERY;.\..\ChibiOS_3.0.2\os\various;.\..\STLib\Inc;.\..\ChibiOS_3.0.2\ext\stdperiph_stm32f4\inc;.\..\hwconf;.\..\applications;.\..\nrf;..\bldc-master;.\..\mcconf;.\..\appconf
  asm misc: --cpreproc --cpu=Cortex-M4.fp  --fpmode=fast
  asm include: .\..\;.\..\ChibiOS_3.0.2\os\rt\ports\ARMCMx;.\..\ChibiOS_3.0.2\os\common\ports\ARMCMx\devices\STM32F4xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\output\project_app.sct
  group applications
    ./../: main.c mc_interface.c mcpwm_foc.c encoder.c
  group appuser
    ./../applications/: app.c app_adc.c app_nunchuk.c app_ppm.c app_sten.c app_uartcomm.c
    ../applications/: dma.c can_my.c
  group hwconf
    ./../ChibiOS_3.0.2/os/hal/boards/ST_STM32F4_DISCOVERY/: board.c
    ../hwconf/: hw_60.c drv8301.c drv8305.c drv8320.c
  group conf
    ./../hwconf/: hw.h
    ./../: conf_general.h chconf.h halconf.h mcuconf.h
    ./../appconf/: appconf_default.h appconf_custom.h appconf_example_ppm.h
    ./../mcconf/: mcconf_sten.h mcconf_default.h
    ../hwconf/: hw_60.h
  group nrf
    ./../nrf/: nrf_driver.c rf.c rfhelp.c spi_sw.c
  group stdperiph_stm32f4
    ./../ChibiOS_3.0.2/ext/stdperiph_stm32f4/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
    ../ChibiOS_3.0.2/ext/stdperiph_stm32f4/src/: stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_can.c
  group ChibiOS/HAL
    ./../ChibiOS_3.0.2/os/hal/osal/rt/: osal.c
    ./../ChibiOS_3.0.2/os/hal/src/: adc.c can.c dac.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c
  group ChibiOS/RT
    ./../ChibiOS_3.0.2/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group ChibiOS/STM32F4xx
    ./../ChibiOS_3.0.2/os/rt/ports/ARMCMx/compilers/RVCT/: chcoreasm_v7m.s
    ./../ChibiOS_3.0.2/os/rt/ports/ARMCMx/: chcore_v7m.c chcore.c
    ./../ChibiOS_3.0.2/os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ./../ChibiOS_3.0.2/os/hal/ports/common/ARMCMx/: nvic.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/STM32F4xx/: adc_lld.c ext_lld_isr.c hal_lld.c stm32_dma.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/: can_lld.c ext_lld.c mac_lld.c sdc_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/DACv1/: dac_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/I2Cv1/: i2c_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/OTGv1/: usb_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/RTCv2/: rtc_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/SPIv1/: i2s_lld.c spi_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c st_lld.c
    ./../ChibiOS_3.0.2/os/hal/ports/STM32/LLD/USARTv1/: serial_lld.c uart_lld.c
  group CMSIS
    ./../ChibiOS_3.0.2/os/ext/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ./../ChibiOS_3.0.2/os/ext/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
  group other
    ./../: buffer.c comm_can.c comm_usb.c comm_usb_serial.c commands.c conf_general.c eeprom.c crc.c digital_filter.c flash_helper.c irq_handlers.c led_external.c ledpwm.c mcpwm.c packet.c servo_dec.c servo_simple.c terminal.c timeout.c utils.c ws2811.c
software components: CMSIS:CORE 4.3.0
